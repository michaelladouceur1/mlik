Commit message: added generate_random_configurations and calculate_forward_kinematics

File: urdf/ur_description/urdf/ur10_robot.urdf (robot description, URDF)
Before this commit: robot ur10, 11 links, 10 joints
Links:
- link tool0: geometry visual sphere radius=0.01
